# Repository DeveloperSungHyun/PicoIno

## KiCad design PicoIno.kicad_pcb

Parts:
C1, C14, C15, C16: 2.2uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C8, C9, C10, C11, C12, C13, C17, C18: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: 47uF; CP_Elec_6.3x5.7
C6: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19, C20: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D; D_MELF
D2, D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J6: signal_V; PinHeader_1x03_P2.54mm_Vertical
J2: POWER; BarrelJack_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J4, J8: 3.3V; PinHeader_1x02_P2.54mm_Vertical
J5, J9: 5V; PinHeader_1x02_P2.54mm_Vertical
J11: Digital_Pin_2; PinSocket_1x08_P2.54mm_Vertical
J12: Digital_Pin_1; PinSocket_1x08_P2.54mm_Vertical
J13: Power_Pin; PinSocket_1x08_P2.54mm_Vertical
J14: analog_Pin; PinSocket_1x06_P2.54mm_Vertical
J15: Debug_Pin; PinHeader_1x03_P2.54mm_Vertical
Q1: IRLML6402TR; VP0610T
Q2: DMG1012T-7; DMG1012T
R1, R2: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R8, R17: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R9, R10: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 5.6K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 200K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R14: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R13: 27; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: BOOTSET; SW_SPST_Omron_B3FS-100xP
SW2: RUN; SW_SPST_Omron_B3FS-100xP
U1, U6: TXS0108EPW; TSSOP-20_4.4x6.5mm_P0.65mm
U2: W25Q16JVUXIQ
U3: LM358; SOIC-8_3.9x4.9mm_P1.27mm
U4: L7805; TO-252-2
U5: AZ1117-3.3; SOT-223-3_TabPin2
U7: RP2B
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C11.1, C13.1, C14.2, U7.23 (VDDC0), U7.45 (LDO_VOUT), U7.50 (VDDC1)
+3V3: C1.2, C2.2, C8.1, C9.1, C10.1, C12.1, C15.1, C17.1, C18.1, J4.1, J8.1, J13.4, Q2.1 (G), R8.2, R16.1, U1.2 (VCCA), U1.10 (OE), U2.8 (VCC), U3.2 (-), U5.2 (VO), U6.2 (VCCA), U6.10 (OE), U7.1 (VDDIO0), U7.10 (VDDIO1), U7.22 (VDDIO2), U7.33 (VDDIO3), U7.42 (VDDIO4), U7.44 (LDO_VIN), U7.48 (USB_VDD), U7.49 (VDDIO5)
+5V: C4.1, J5.1, J9.1, J13.2, J13.5, Q1.2 (S), R5.1, U3.8 (V+), U4.3 (OUT), U5.3 (VI)
/ADC_VREF: R15.2, R16.2
/GPIO_0: U1.9 (A8), U7.2 (GPIO0)
/GPIO_1: U1.8 (A7), U7.3 (GPIO1)
/GPIO_2: U1.7 (A6), U7.4 (GPIO2)
/GPIO_3: U1.6 (A5), U7.5 (GPIO3)
/GPIO_4: U1.5 (A4), U7.6 (GPIO4)
/GPIO_5: U1.4 (A3), U7.7 (GPIO5)
/GPIO_6: U1.3 (A2), U7.8 (GPIO6)
/GPIO_7: U1.1 (A1), U7.9 (GPIO7)
/GPIO_8: U6.7 (A6), U7.11 (GPIO8)
/GPIO_9: U6.6 (A5), U7.12 (GPIO9)
/GPIO_10: U6.5 (A4), U7.13 (GPIO10)
/GPIO_11: U6.4 (A3), U7.14 (GPIO11)
/GPIO_12: U6.3 (A2), U7.15 (GPIO12)
/GPIO_13: R11.2, U6.1 (A1), U7.16 (GPIO13)
/GPIO_14: U7.17 (GPIO14)
/GPIO_15: U7.18 (GPIO15)
/GPIO_16: U7.27 (GPIO16)
/GPIO_17: U7.28 (GPIO17)
/GPIO_18: U7.29 (GPIO18)
/GPIO_19: U7.30 (GPIO19)
/GPIO_20: U7.31 (GPIO20)
/GPIO_21: U7.32 (GPIO21)
/GPIO_22: U7.34 (GPIO22)
/GPIO_24: R4.1, R5.2, U7.36 (GPIO24)
/GPIO_25: U7.37 (GPIO25)
/GPIO_26(ADC0): J14.1, U7.38 (GPIO26_ADC0)
/GPIO_27(ADC1): J14.2, U7.39 (GPIO27_ADC1)
/GPIO_28(ADC2): J14.3, U7.40 (GPIO28_ADC2)
/GPIO_29(ADC3): Q2.2 (S), U7.41 (GPIO29_ADC3)
/QSPI_CK: U2.6 (CLK), U7.52 (QSPI_CK)
/QSPI_D0: U2.5 (DI_IO0), U7.53 (QSPI_D0)
/QSPI_D1: U2.2 (DI_IO1), U7.55 (QSPI_D1)
/QSPI_D2: U2.3 (~WP_IO2), U7.54 (QSPI_D2)
/QSPI_D3: U2.7 (~HOLD_IO3), U7.51 (QSPI_D3)
/QSPI_SS: R3.1, U2.1 (~CS), U7.56 (QSPI_SS)
/RUN: J13.3, SW2.1, U7.26 (RUN)
/SWCLK: J15.1, U7.24 (SWCLK)
/SWDIO: J15.3, U7.25 (SWDIO)
/USB_D+: J3.A6 (D+), J3.B6 (D+), R12.2
/USB_D-: J3.A7 (D-), J3.B7 (D-), R13.1
/VSYS: R6.1
/Vin: C3.1, D1.1 (K), J13.8, R9.1, U4.1 (IN)
/XI: C19.1, U7.20 (XI), Y1.1
/XO: R17.1, U7.21 (XO)
/_GPIO_0: J12.8, U1.12 (B8)
/_GPIO_1: J12.7, U1.13 (B7)
/_GPIO_2: J12.6, U1.14 (B6)
/_GPIO_3: J12.5, U1.15 (B5)
/_GPIO_4: J12.4, U1.16 (B4)
/_GPIO_5: J12.3, U1.17 (B3)
/_GPIO_6: J12.2, U1.18 (B2)
/_GPIO_7: J12.1, U1.20 (B1)
/_GPIO_8: J11.8, U6.14 (B6)
/_GPIO_9: J11.7, U6.15 (B5)
/_GPIO_10: J11.6, U6.16 (B4)
/_GPIO_11: J11.5, U6.17 (B3)
/_GPIO_12: J11.4, U6.18 (B2)
/_GPIO_13: J11.3, U6.20 (B1)
/power: D1.2 (A), J2.1, J13.1
GND: C1.1, C2.1, C3.2, C4.2, C6.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D2.1 (K), D3.1 (K), J2.2, J2.3, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J11.2, J13.6, J13.7, J15.2, R1.2, R2.2, R4.2, R7.2, R10.1, R14.1, SW1.2, SW2.2, U1.11 (GND), U2.4 (GND), U3.4 (V-), U4.2 (GND), U5.1 (GND), U6.11 (GND), U7.19 (TESTEN), U7.57 (GND), Y1.2, Y1.4
unnamed: C6.2, Q2.3 (D), R6.2, R7.1
unnamed: C16.1, R15.1, U7.43 (ADC_AVDD)
unnamed: C20.1, R17.2, Y1.3
unnamed: D2.2 (A), R8.1
unnamed: D3.2 (A), R11.1
unnamed: J1.1, J1.2
unnamed: J1.3, J4.2, J5.2, U1.19 (VCCB)
unnamed: J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), Q1.3 (D)
unnamed: J3.A5 (CC1), R1.1
unnamed: J3.B5 (CC2), R2.1
unnamed: J6.1, J6.2
unnamed: J6.3, J8.2, J9.2, U6.19 (VCCB)
unnamed: Q1.1 (G), U3.1
unnamed: R3.2, SW1.1
unnamed: R9.2, R10.2, U3.3 (+)
unnamed: R12.1, U7.47 (USB_DP)
unnamed: R13.2, U7.46 (USB_DM)
unnamed: R14.2, U7.35 (GPIO23)

Notes on the sheet:
SCL
SDA
USB_Power
전원부
DC_POWER
MCU
Pin_con
2 ~ 3.3K

Board: 2 copper layers, 68.6 x 53.3 mm, 67 parts (0 on the bottom side), 71 nets.

Other parts of the board:
P5, P6, P7, P8: CONN_01X01; Arduino_1pin

## Commit log

2024-01-30 version 1.1.0
